Commit message: update readme

File: assets/objects/urdf/cross.urdf (robot description, URDF)
Before this commit: robot cross, 2 links, 1 joints
Joints:
- joint world_to_indenter: origin xyz=0.0 0.0 0.0 rpy=0.0 0.0 0.0 -> xyz=0.0 0.0013 0.0 rpy=0.0 0.0 0.0
